options:
  parameters:
    author: diego
    generate_options: qt_gui
    id: hybridsdr_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amalthea_device_0
  id: amalthea_device
  parameters:
    vcd_path: ''''''
    write_vcd: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: amalthea_demod_0
  id: amalthea_demod
  parameters: {}
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '1'
    minimum: '-1'
    seed: '0'
    type: byte
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '20'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from luna import top_level_cli
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '10240'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.amalthea_device.flash()
      self.amalthea_device.finalize_usb_connections(self)
    section: main_after_init
  states: {}

connections:
- [amalthea_demod_0, '0', blocks_abs_xx_0, '0']
- [amalthea_demod_0, '1', qtgui_time_sink_x_0_0, '0']
- [amalthea_demod_0, '2', qtgui_time_sink_x_0, '1']
- [analog_random_uniform_source_x_0, '0', digital_gmsk_mod_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', amalthea_demod_0, '0']

metadata:
  file_format: 1
